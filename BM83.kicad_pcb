# Repository Yu-hotspring/BM83

File README.md:

| Designator | Footprint | Quantity | Value | URL |
|------------|-----------|----------|-------|-----|
| C101, C102, C103, C108, C110, C111, C301, C302, C303, C401, C402 | 1206 | 11 | 0.1u | [URL](https://www.digikey.jp/ja/products/detail/walsin-technology-corporation/1206B104K500CT/9355102) |
| C104, C105, C106, C107, C121 | CP_Radial_D16.0mm_P7.50mm | 5 | 1000u | [URL](https://akizukidenshi.com/catalog/g/g108442/) |
| C109, C112 | CP_Radial_D10.0mm_P5.00mm | 2 | 470u | [URL](https://akizukidenshi.com/catalog/g/g102719/) |
| C113, C114 | 1206 | 2 | 4.7u | [URL](https://akizukidenshi.com/catalog/g/g115634/) |
| C115, C116 | 0603 | 2 | 4.7u | [URL](https://akizukidenshi.com/catalog/g/g109218/) |
| C117, C118, C202, C203, C304, C310 | C_Rect_L7.2mm_W6.0mm_P5.00mm | 6 | 1u | [URL](https://akizukidenshi.com/catalog/g/g114602/) |
| C119 | 0603 | 1 | 0.33u | [URL](https://www.digikey.jp/ja/products/detail/samsung-electro-mechanics/CL10B334KO8NNNC/3887706) |
| C120 | 0603 | 1 | 2.2u | [URL](https://akizukidenshi.com/catalog/g/g116077/) |
| C201, C204 | 0402 | 2 | 2.2n | [URL](https://www.digikey.jp/ja/products/detail/kemet/C0402C222J3GEC7411/8645834) |
| C205, C212 | 0402 | 2 | 2.2u | [URL](https://www.digikey.jp/ja/products/detail/taiyo-yuden/LMK105BJ225KV-F/7403747) |
| C206, C208, C210, C213, C216, C219, C215 | 0402 | 7 | 0.1u | [URL](https://www.digikey.jp/ja/products/detail/murata-electronics/GRM155R71H104KE14D/4906220) |
| C207, C209, C211, C214 | CP_Elec_3x5.3 | 4 | 10u | [URL](https://www.digikey.jp/ja/products/detail/w%C3%BCrth-elektronik/865090368008/9836336) |
| C217 | 0402 | 1 | 0.01u | [URL](https://www.digikey.jp/ja/products/detail/cal-chip-electronics-inc/GMC04X7R103K50NT/22461304) |
| C218 | 0402 | 1 | 4.7u | [URL](https://www.digikey.jp/ja/products/detail/taiyo-yuden/JMK105BBJ475MV-F/2573874) |
| C305, C311 | C_Rect_L7.2mm_W2.5mm_P5.00mm | 2 | 0.1u | [URL](https://akizukidenshi.com/catalog/g/g114597/) |
| C306, C312 | C_Rect_L7.2mm_W2.5mm_P5.00mm | 2 | 0.01u | [URL](https://akizukidenshi.com/catalog/g/g114592/) |
| C307, C313 | C_Rect_L7.2mm_W3.5mm_P5.00mm | 2 | 0.22u | [URL](https://akizukidenshi.com/catalog/g/g114599/) |
| C308, C314 | C_Rect_L7.2mm_W2.5mm_P5.00mm | 2 | 0.022u | [URL](https://akizukidenshi.com/catalog/g/g114594/) |
| C309, C315 | C_Rect_L7.2mm_W2.5mm_P5.00mm | 2 | 2200p | [URL](https://akizukidenshi.com/catalog/g/g114589/) |
| D101, D102 | LED_D3.0mm_Horizontal_O1.27mm_Z2.0mm | 2 | LED | [URL](https://akizukidenshi.com/catalog/g/g111577/) |
| D103 | LED_D3.0mm_Horizontal_O1.27mm_Z2.0mm | 1 | LED | [URL](https://akizukidenshi.com/catalog/g/g111639/) |
| D104, D105 | LED_D3.0mm_Horizontal_O1.27mm_Z2.0mm | 2 | LED | [URL](https://akizukidenshi.com/catalog/g/g111637/) |
| D106, D110 | US2H | 2 | CUHS20S60 | [URL](https://akizukidenshi.com/catalog/g/g116578/) |
| D107 | D_SOD-123F | 1 | SMF24A | [URL](https://www.digikey.sg/en/products/detail/littelfuse-inc/SMF24A/3672403) |
| D108, D109 | D_SOD-882 | 2 | PESD5V0S1UL | [URL](https://www.digikey.sg/en/products/detail/nexperia-usa-inc/PESD5V0S1ULSYL/16368528) |
| D111, D112 | US2H | 2 | CUHS20F30 | [URL](https://akizukidenshi.com/catalog/g/g116577/) |
| F101 | MFRX110720 | 1 | Polyfuse | [URL](https://akizukidenshi.com/catalog/g/g113586/) |
| FB101 | 0603 | 1 | 60 | [URL](https://akizukidenshi.com/catalog/g/g104442/) |
| FB102 | 0805 | 1 | 33 | [URL](https://akizukidenshi.com/catalog/g/g106982/) |
| IC101 | TO-252-2 | 1 | NJM2845DL1-33 | [URL](https://akizukidenshi.com/catalog/g/g111299/) |
| J101 | USB_C_Receptacle_HRO_TYPE-C-31-M-12 | 1 | USB_C_Receptacle_USB2.0 | [URL](https://akizukidenshi.com/catalog/g/g114356/) |
| J102, J105 | JST_VH_B2P-VH_1x02_P3.96mm_Vertical | 2 | JST_VH | [URL](https://www.digikey.jp/ja/products/detail/jst-sales-america-inc/B2P-VH/926547) |
| J103 | BarrelJack_Horizontal | 1 | Jack-DC | [URL](https://akizukidenshi.com/catalog/g/g106568/) |
| J104 | fuse_holder | 1 | 3557-2 | [URL](https://www.digikey.jp/ja/products/detail/keystone-electronics/3557-2/2137305) |
| J106 | MJ-8435 | 1 | AudioJack3 | [URL](https://akizukidenshi.com/catalog/g/g109060/) |
| K101 | Relay_SPDT_Omron_G2RL-1-E | 1 | G2R-1-E 24V | [URL](https://ja.aliexpress.com/item/1005009611697631.html?spm=a2g0o.productlist.main.1.62fa2dd1VOfFZu&algo_pvid=65fa2de3-492f-428a-b828-fd0b0800f81e&pdp_ext_f=%7B%22order%22%3A%221273%22%2C%22eval%22%3A%221%22%2C%22fromPage%22%3A%22search%22%7D&utparam-url=scene%3Asearch%7Cquery_from%3A%7Cx_object_id%3A1005009611697631%7C_p_origin_prod%3A) |
| L101, L102 | 744774033 | 2 | 3.3u | [URL](https://www.digikey.jp/ja/products/detail/w%C3%BCrth-elektronik/744774033/1638670?s=N4IgTCBcDaIAQHYAsSHIAwGZNxAXQF8g) |
| LED201, LED202 | LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm | 2 | WS2812B | [URL](https://akizukidenshi.com/catalog/g/g131923/) |
| PS101 | M78A | 1 | M78AR05-0.5 | [URL](https://akizukidenshi.com/catalog/g/g107179/) |
| PS102 | M78A | 1 | M78AR033-0.5 | [URL](https://akizukidenshi.com/catalog/g/g107178/) |
| Q101 | TO-92L_Inline_Wide | 1 | 2SC1815 | [URL](https://akizukidenshi.com/catalog/g/g117089/) |
| Q102 | TO-92L_Inline_Wide | 1 | 2SA1015 | [URL](https://akizukidenshi.com/catalog/g/g117091/) |
| Q401, Q402, Q407, Q408, Q409, Q410, Q415, Q416 | SOT-23-6 | 8 | TPC6901A | [URL](https://akizukidenshi.com/catalog/g/g113875/) |
| Q403, Q404, Q411, Q412 | TO-126-3_Vertical | 4 | 2SA1359 | [URL](https://akizukidenshi.com/catalog/g/g110042/) |
| Q405, Q406, Q413, Q414 | TO-126-3_Vertical | 4 | 2SC3422 | [URL](https://akizukidenshi.com/catalog/g/g109669/) |
| R101, R102, R103, R104, R105, R111, R113, R205, R206, R411, R412, R413, R414, R417, R418, R421, R422 | 0603 | 17 | 10k | [URL](https://akizukidenshi.com/catalog/g/g130355/) |
| R106, R401, R402, R409, R410, R419, R420, R427, R428 | 2512 | 9 | 1k | [URL](https://akizukidenshi.com/catalog/g/g109461/) |
| R107 | 0603 | 1 | 200k | [URL](https://www.digikey.jp/ja/products/detail/susumu/RG1608P-204-B-T5/1240508) |
| R108, R109 | 0603 | 2 | 5.1k | [URL](https://akizukidenshi.com/catalog/g/g130338/) |
| R110 | CEMENT_RESISTOR_5W | 1 | 50 | [URL](https://akizukidenshi.com/catalog/g/g103995/) |
| R112 | 0603 | 1 | 220 | [URL](https://akizukidenshi.com/catalog/g/g113833/) |
| R114, R115, R201, R204 | 0603 | 4 | 100k | [URL](https://akizukidenshi.com/catalog/g/g130357/) |
| R202, R203 | 0603 | 2 | 470 | [URL](https://akizukidenshi.com/catalog/g/g130349/) |
| R207, R209 | 0603 | 2 | 13.3k | [URL](https://www.digikey.jp/ja/products/detail/panasonic-industry/ERJ-3EKF1332V/196112) |
| R208, R210, R211 | 0603 | 3 | 1k | [URL](https://akizukidenshi.com/catalog/g/g111790/) |
| R301, R302, R309, R310 | 0603 | 4 | 3.3k | [URL](https://www.digikey.jp/ja/products/detail/yageo/RC0603FR-073K3L/727126) |
| R303, R304, R305, R311, R312, R313 | 0603 | 6 | 1.21k | [URL](https://www.digikey.jp/ja/products/detail/yageo/RC0603FR-071K21L/726854) |
| R306, R307, R308, R314, R315, R316 | 0603 | 6 | 26.7k | [URL](https://www.digikey.jp/ja/products/detail/panasonic-industry/ERJ-3EKF2672V/196248) |
| R403, R404, R405, R406, R423, R424, R425, R426 | R_Box_L13.0mm_W4.0mm_P9.00mm | 8 | 0.22 | [URL](https://akizukidenshi.com/catalog/g/g117487/) |
| R407, R408, R415, R416 | 0603 | 4 | 40k | [URL](https://www.digikey.jp/ja/products/detail/yageo/RT0603BRD0740KL/7708329) |
| RV301, RV302, RV303 | RV_2C | 3 | 10k | [URL](https://akizukidenshi.com/catalog/g/g112576/) |
| RV401 | RK12L12C | 1 | R | [URL](https://akizukidenshi.com/catalog/g/g117473/) |
| SW101 | SW_E-Switch_EG2219_DPDT_Angled | 1 | SW_Slide_DPDT | [URL](https://akizukidenshi.com/catalog/g/g115702/) |
| SW102 | JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical | 1 | SW_SPST | [URL](https://akizukidenshi.com/catalog/g/g112247/) |
| SW201 | TVAF06A020BR | 1 | SW_Push | [URL](https://akizukidenshi.com/catalog/g/g114888/) |
| SW202 | SKHHLPA010 | 1 | SW_Push | [URL](https://akizukidenshi.com/catalog/g/g107193/) |
| U101 | SOT-23-6 | 1 | CH221K | [URL](https://akizukidenshi.com/catalog/g/g118022/) |
| U102 | DIP-8_W7.62mm_Socket | 1 | LM358N | [URL](https://akizukidenshi.com/catalog/g/g111167/) |
| U201 | TSSOP-20_4.4x6.5mm_P0.65mm | 1 | PCM5102A | [URL](https://www.digikey.jp/ja/products/detail/texas-instruments/PCM5102AQPWRQ1/4725759) |
| U202 | Microchip_BM83 | 1 | Microchip_BM83 | [URL](https://akizukidenshi.com/catalog/g/g130004/) |
| U203 | JST_PH_B8B-PH-K_1x08_P2.00mm_Vertical | 1 | ST7735S | [URL](https://akizukidenshi.com/catalog/g/g112808/) |
| U204 | LQFP-32_7x7mm_P0.8mm | 1 | STM32G431KBTx | [URL](https://www.digikey.jp/ja/products/detail/stmicroelectronics/STM32G431KBT6/10231564) |
| U301 | DIP-8_W7.62mm_Socket | 1 | TL072 | [URL](https://akizukidenshi.com/catalog/g/g116263/) |
| U302, U303 | DIP-14_W7.62mm_Socket | 2 | TL074 | [URL](https://akizukidenshi.com/catalog/g/g116093/) |
| U401, U402 | DIP-14_W7.62mm_Socket | 2 | LME49740NA | [URL](https://akizukidenshi.com/catalog/g/g103685/) |

## その他の部品

| 部品名 | Quantity | URL |
|--------|----------|-----|
| ミサイルスイッチ | 1 | [URL](https://akizukidenshi.com/catalog/g/g107058/) |
| OLED | 1 | [URL](https://www.amazon.co.jp/dp/B0CBX29957) |
| つまみ1 | 4 | [URL](https://akizukidenshi.com/catalog/g/g112202/) |
| つまみ2 | 1 | [URL](https://akizukidenshi.com/catalog/g/g112530/) |
| ヒートシンク | 1 | [URL](https://eleshop.jp/shop/g/g1850031/) |

## KiCad design BM83.kicad_pcb

Parts:
C101, C102, C103, C108, C110, C111: 0.1u; C_1206_3216Metric
C104, C105, C106, C107, C121: 1000u; CP_Radial_D16.0mm_P7.50mm
C109, C112: 470u; CP_Radial_D10.0mm_P5.00mm
C113, C114: 4.7u; C_1206_3216Metric
C115, C116: 4.7u; C_0603_1608Metric
C117, C118: 1u; C_Rect_L7.2mm_W6.0mm_P5.00mm
C119: 0.33u; C_0603_1608Metric
C120: 2.2u; C_0603_1608Metric
D101, D102, D103, D104, D105: LED; LED_D3.0mm_Horizontal_O1.27mm_Z2.0mm
D106, D110: ?; CUHS20F30H3F
D107: SMF24A; D_SOD-123F
D108, D109: PESD5V0S1UL; D_SOD-882
D111, D112: D; CUHS20F30H3F
F101: Polyfuse; MFRX110720
FB101: 60; L_0603_1608Metric
FB102: 33; L_0805_2012Metric
H101, H102, H103, H104: M3; MountingHole_3.2mm_M3_Pad_Via
IC101: NJM2845DL1-33; TO-252-2; Manufacturer_Part_Number NJM2845DL1-33-TE1; Mouser Part Number 513-NJM2845DL133-TE1
J101: USB_C_Receptacle_USB2.0; USB_C_Receptacle_HRO_TYPE-C-31-M-12
J102, J105: JST_VH; JST_VH_B2P-VH_1x02_P3.96mm_Vertical
J103: Jack-DC; BarrelJack_Horizontal
J104: 3557-2; fuse_holder; Manufacturer_Part_Number 3557-2; Mouser Part Number 534-3557-2
J106: AudioJack3; MJ-8435
JP101, JP102: Jumper_3; SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm
K101: G2R-1-E 24V; Relay_SPDT_Omron_G2RL-1-E; Manufacturer_Part_Number DG85B-7011-75-1024
L101, L102: 3.3u; 744774033
PS101: M78AR05-0.5; M78A; Manufacturer_Part_Number M78AR05-0.5
PS102: M78AR033-0.5; M78A; Manufacturer_Part_Number M78AR033-0.5
Q101: 2SC1815; TO-92L_Inline_Wide
Q102: 2SA1015; TO-92L_Inline_Wide
R101, R102, R103, R104, R105, R111, R113: 10k; R_0603_1608Metric
R106: 1k; R_2512_6332Metric
R107: 200k; R_0603_1608Metric
R108, R109: 5.1k; R_0603_1608Metric
R110: 50; CEMENT_RESISTOR_5W
R112: 220; R_0603_1608Metric
R114, R115: 100k; R_0603_1608Metric
SW101: SW_Slide_DPDT; SW_E-Switch_EG2219_DPDT_Angled
SW102: SW_SPST; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
U101: CH221K; SOT-23-6
U102: LM358N; DIP-8_W7.62mm_Socket

Connections:
+3.3V: C120.1, D104.2 (A), IC101.3 (VOUT); also elsewhere on the board
+3.3VA: D105.2 (A), PS102.3 (VOUT); also elsewhere on the board
+5V: C115.1, C119.1, D103.2 (A), IC101.1 (VIN), L102.1, PS101.3 (VOUT); also elsewhere on the board
/Amplifier/OUT_L+: J102.1; also elsewhere on the board
/Amplifier/OUT_L-: J102.2; also elsewhere on the board
/Amplifier/OUT_R+: J105.1; also elsewhere on the board
/Amplifier/OUT_R-: J105.2; also elsewhere on the board
/BM83_D+: SW101.6 (A); also elsewhere on the board
/BM83_D-: SW101.3 (C); also elsewhere on the board
/DM: D108.1 (K), J101.A7 (D-), J101.B7 (D-), JP102.2 (C)
/DP: D109.1 (K), J101.A6 (D+), J101.B6 (D+), JP101.2 (C)
/SIG_L: C117.2, R114.1; also elsewhere on the board
/SIG_R: C118.1, R115.1; also elsewhere on the board
/STM32_D+: SW101.4 (C); also elsewhere on the board
/STM32_D-: SW101.1 (A); also elsewhere on the board
/SWCLK: JP101.1 (A); also elsewhere on the board
/SWDIO: JP102.1 (A); also elsewhere on the board
/USB_D+: JP101.3 (B), SW101.5 (B)
/USB_D-: JP102.3 (B), SW101.2 (B)
AGND: C101.1, C102.2, C103.2, C104.2, C105.2, C106.2, C107.2, C110.2, C111.2, C112.2, C113.2, C114.2, C115.2, C116.2, C119.2, C120.2, C121.2, D107.2 (A), D108.2 (A), D109.2 (A), D110.2 (A), D112.2 (A), FB101.2, H101.1 (1_1), H102.1 (1_1), H103.1 (1_1), H104.1 (1_1), IC101.2 (GND), J101.A1 (GND), J101.A12 (GND), J101.B1 (GND), J101.B12 (GND), J103.2, J106.S, K101.A2 (COIL_2), PS101.2 (GND), PS102.2 (GND), Q102.1 (C), R101.2, R102.2, R103.2, R104.2, R105.2, R108.2, R109.2, R113.2, U101.2 (GND), U102.4 (V-); also elsewhere on the board
GNDREF: C108.2, C109.2, C111.1, C112.1, D111.2 (A), D112.1 (K), Q101.3 (E), Q102.3 (E), R114.2, R115.2, U102.2 (-), U102.5 (+); also elsewhere on the board
unnamed: C117.1, J106.T
unnamed: C118.2, J106.R
unnamed: D101.1 (K), R101.1
unnamed: D102.1 (K), R102.1
unnamed: D103.1 (K), R103.1
unnamed: D104.1 (K), R104.1
unnamed: D105.1 (K), R105.1
unnamed: C101.2, D106.2 (A), D107.1 (K), F101.1, R106.1
unnamed: D110.1 (K), K101.A1 (COIL_1), SW102.2 (B)
unnamed: F101.2, J101.A4 (VBUS), J101.A9 (VBUS), J101.B4 (VBUS), J101.B9 (VBUS)
unnamed: FB102.1, J103.1
unnamed: J101.A5 (CC1), R109.1, U101.4 (CC1)
unnamed: J101.B5 (CC2), R108.1, U101.5 (CC2)
unnamed: FB101.1, J101.S1 (SHIELD)
unnamed: J104.2, J104.4, K101.11 (COM), R110.1, SW102.1 (A)
unnamed: C114.1, L101.2, PS101.1 (VIN)
unnamed: C116.1, L102.2, PS102.1 (VIN)
unnamed: Q101.2 (B), Q102.2 (B), R112.2
unnamed: R112.1, U102.1
unnamed: R107.2, U101.6 (CFG)
unnamed: C102.1, R106.2, R107.1, U101.1 (VDD)
unnamed: R111.2, R113.1, U102.3 (+)
unnamed: U102.6 (-), U102.7
V+: C104.1, C105.1, C106.1, C107.1, C108.1, C109.1, C110.1, C113.1, C121.1, D102.2 (A), D111.1 (K), K101.14 (NO), L101.1, Q101.1 (C), R110.2, R111.1, U102.8 (V+); also elsewhere on the board
VIN: C103.1, D101.2 (A), D106.1 (K), FB102.2, J104.1, J104.3

Notes on the sheet:
←@20V,4000uF
双二次フィルタの話
SBD
DCDCコンバータ・レギュレータ
1000uF
ダーリントン接続
インダクタ
フェライトビーズ
給電(ACアダプタ)
ST7735S接続参考
リレー
両電源生成
ライン入力
Peak 2.82[W] t_{90%}=0.4692[s]
(このスイッチをONした状態で電源接続した際のフールプルーフは)ないです
OLEDこれ？
Polyfuse
BM83モジュールの設定について
書き込み/UAC接続/給電(USB-PD)
ミサイルスイッチ
TVS for VBUS
TVS for DPDM
↑接続先確認(AGNDではないか)
つまみ
インバーテッドダーリントン
ダイヤモンドバッファ
定電流回路とかの話
DPDT
1kR 6432 2W
電解コンデンサ

Parts:
C201, C204: 2.2n; C_0402_1005Metric
C202, C203: 1u; C_Rect_L7.2mm_W6.0mm_P5.00mm
C205, C212: 2.2u; C_0402_1005Metric
C206, C208, C210, C213, C215, C216, C219: 0.1u; C_0402_1005Metric
C207, C209, C211, C214: 10u; CP_Elec_3x5.3
C217: 0.01u; C_0402_1005Metric
C218: 4.7u; C_0402_1005Metric
LED201, LED202: WS2812B; LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm
R201, R204: 100k; R_0603_1608Metric
R202, R203: 470; R_0603_1608Metric
R205, R206: 10k; R_0603_1608Metric
R207, R209: 13.3k; R_0603_1608Metric
R208, R210, R211: 1k; R_0603_1608Metric
SW201: SW_Push; TVAF06A020BR
SW202: SW_Push; SKHHLPA010
U201: PCM5102A; TSSOP-20_4.4x6.5mm_P0.65mm
U202: Microchip_BM83
U203: ST7735S; JST_PH_B8B-PH-K_1x08_P2.00mm_Vertical
U204: STM32G431KBTx; LQFP-32_7x7mm_P0.8mm

Connections:
+3.3V: C206.1, C207.1, C218.1, C219.1, R205.1, U201.20 (DVDD), U203.2 (VCC), U203.5 (RES), U204.1 (VDD), U204.17 (VDD); also elsewhere on the board
+3.3VA: C210.1, C211.1, C213.1, C214.1, C216.1, C217.1, U201.1 (CPVDD), U201.8 (AVDD), U204.15 (VDDA); also elsewhere on the board
+5V: LED201.1 (VDD), LED202.1 (VDD), U202.22 (ADAP_IN); also elsewhere on the board
/BM83_D+: U202.37 (DP); also elsewhere on the board
/BM83_D-: U202.36 (DM); also elsewhere on the board
/DAC/BCK: U201.13 (BCK), U202.3 (SCLK1), U204.26 (PB3)
/DAC/DIN: U201.14 (DIN), U202.4 (DT1), U204.28 (PB5)
/DAC/LDOO: C208.2, C209.1, U201.18 (LDOO)
/DAC/LED1: U202.32 (LED1)
/DAC/LED2: U202.34 (LED2)
/DAC/LRCK: U201.15 (LRCK), U202.2 (RFS1), U204.25 (PA15)
/DAC/MISO: U203.6 (DC), U204.11 (PA6)
/DAC/MOSI: U203.4 (SDA), U204.12 (PA7)
/DAC/PA0: R206.1, U202.26 (PWR(MFB)), U204.5 (PA0)
/DAC/PA4_SW: R211.1, SW202.2, U204.9 (PA4)
/DAC/PB0: LED201.4 (DI), U204.13 (PB0)
/DAC/RESET: C215.1, SW201.2, U204.4 (PG10)
/DAC/SCK: U203.3 (SCL), U204.10 (PA5)
/DAC/UART_RX_STM: U202.30 (P8_5/UART_TXD), U204.8 (PA3)
/DAC/UART_TX_STM: U202.29 (P8_6/UART_RXD), U204.7 (PA2)
/DAC/VNEG: C212.2, U201.5 (VNEG)
/DAC/external codec reset: U202.49 (P0_0/UART_TX_IND)
/DAC/foward: U202.44 (P0_1)
/DAC/play/pause: U202.33 (P0_2)
/DAC/reverse: U202.38 (P0_3)
/DAC/volume_down: U202.40 (P0_5)
/DAC/volume_up: U202.39 (P2_7)
/SIG_L: C202.2, R201.2; also elsewhere on the board
/SIG_R: C203.1, R204.1; also elsewhere on the board
/STM32_D+: U204.22 (PA12); also elsewhere on the board
/STM32_D-: U204.21 (PA11); also elsewhere on the board
/SWCLK: U204.24 (PA14); also elsewhere on the board
/SWDIO: U204.23 (PA13); also elsewhere on the board
AGND: C201.1, C204.2, C206.2, C207.2, C208.1, C209.2, C210.2, C211.2, C212.1, C213.2, C214.2, C215.2, C216.2, C217.2, C218.2, C219.2, LED201.3 (GND), LED202.3 (GND), R206.2, R208.1, R210.2, R211.2, SW201.1, SW202.1, U201.3 (CPGND), U201.9 (AGND), U201.10 (DEMP), U201.11 (FLT), U201.12 (SCK), U201.16 (FMT), U201.19 (DGND), U202.16 (GND), U202.50 (GND), U202.56 (GND), U202.57 (GND), U203.1 (GND), U203.7 (CS), U204.14 (VSSA), U204.16 (VSS), U204.32 (VSS); also elsewhere on the board
GNDREF: R201.1, R204.2; also elsewhere on the board
unnamed: C201.2, R202.2, R207.1
unnamed: C202.1, R207.2, R208.2
unnamed: C203.2, R209.1, R210.1
unnamed: C204.1, R203.1, R209.2
unnamed: LED201.2 (DO), LED202.4 (DI)
unnamed: C205.2, U201.4 (CAPM)
unnamed: C205.1, U201.2 (CAPP)
unnamed: R202.1, U201.6 (OUTL)
unnamed: R203.2, U201.7 (OUTR)
unnamed: R205.2, U201.17 (XSMT)

Notes on the sheet:
2.2Vくらいだった気がする
10uF

Parts:
C301, C302, C303: 0.1u; C_1206_3216Metric
C304, C310: 1u; C_Rect_L7.2mm_W6.0mm_P5.00mm
C305, C311: 0.1u; C_Rect_L7.2mm_W2.5mm_P5.00mm
C306, C312: 0.01u; C_Rect_L7.2mm_W2.5mm_P5.00mm
C307, C313: 0.22u; C_Rect_L7.2mm_W3.5mm_P5.00mm
C308, C314: 0.022u; C_Rect_L7.2mm_W2.5mm_P5.00mm
C309, C315: 2200p; C_Rect_L7.2mm_W2.5mm_P5.00mm
R301, R302, R309, R310: 3.3k; R_0603_1608Metric
R303, R304, R305, R311, R312, R313: 1.21k; R_0603_1608Metric
R306, R307, R308, R314, R315, R316: 26.7k; R_0603_1608Metric
RV301, RV302, RV303: 10k; RV_2C
U301: TL072; DIP-8_W7.62mm_Socket
U302, U303: TL074; DIP-14_W7.62mm_Socket

Connections:
/Amplifier/EQ_L: R301.2, U302.14; also elsewhere on the board
/Amplifier/EQ_R: R309.2, U303.14; also elsewhere on the board
/SIG_L: U301.5 (+); also elsewhere on the board
/SIG_R: U301.3 (+); also elsewhere on the board
AGND: C301.2, C302.2, C303.2, U301.4 (V-), U302.11 (V-), U303.11 (V-); also elsewhere on the board
GNDREF: R306.2, R307.2, R308.2, R314.2, R315.2, R316.2; also elsewhere on the board
unnamed: C304.1, RV301.2
unnamed: C304.2, C307.1, R303.1
unnamed: C305.1, RV302.2
unnamed: C305.2, C308.1, R304.1
unnamed: C306.1, RV303.2
unnamed: C306.2, C309.1, R305.1
unnamed: C310.1, RV301.5
unnamed: C310.2, C313.1, R311.1
unnamed: C311.1, RV302.5
unnamed: C311.2, C314.1, R312.1
unnamed: C312.1, RV303.5
unnamed: C312.2, C315.1, R313.1
unnamed: R310.1, U301.1, U301.2 (-)
unnamed: R302.1, U301.6 (-), U301.7
unnamed: C307.2, R306.1, U302.3 (+)
unnamed: R303.2, U302.1, U302.2 (-)
unnamed: C308.2, R307.1, U302.5 (+)
unnamed: R304.2, U302.6 (-), U302.7
unnamed: C309.2, R308.1, U302.10 (+)
unnamed: R305.2, U302.8, U302.9 (-)
unnamed: R302.2, RV301.3, RV302.3, RV303.3, U302.12 (+)
unnamed: R301.1, RV301.1, RV302.1, RV303.1, U302.13 (-)
unnamed: C313.2, R314.1, U303.3 (+)
unnamed: R311.2, U303.1, U303.2 (-)
unnamed: C314.2, R315.1, U303.5 (+)
unnamed: R312.2, U303.6 (-), U303.7
unnamed: C315.2, R316.1, U303.10 (+)
unnamed: R313.2, U303.8, U303.9 (-)
unnamed: R310.2, RV301.6, RV302.6, RV303.6, U303.12 (+)
unnamed: R309.1, RV301.4, RV302.4, RV303.4, U303.13 (-)
V+: C301.1, C302.1, C303.1, U301.8 (V+), U302.4 (V+), U303.4 (V+); also elsewhere on the board

Notes on the sheet:
60Hz
バッファ
RK0972B103L15F
6kHz
600Hz

Parts:
C401, C402: 0.1u; C_1206_3216Metric
Q401, Q402, Q407, Q408, Q409, Q410, Q415, Q416: TPC6901A; SOT-23-6
Q403, Q404, Q411, Q412: 2SA1359; TO-126-3_Vertical
Q405, Q406, Q413, Q414: 2SC3422; TO-126-3_Vertical
R401, R402, R409, R410, R419, R420, R427, R428: 1k; R_2512_6332Metric
R403, R404, R405, R406, R423, R424, R425, R426: 0.22; R_Box_L13.0mm_W4.0mm_P9.00mm
R407, R408, R415, R416: 40k; R_0603_1608Metric
R411, R412, R413, R414, R417, R418, R421, R422: 10k; R_0603_1608Metric
RV401: R; RK12L12C
U401, U402: LME49740NA; DIP-14_W7.62mm_Socket

Connections:
/Amplifier/EQ_L: RV401.4; also elsewhere on the board
/Amplifier/EQ_R: RV401.1; also elsewhere on the board
/Amplifier/OUT_L+: R423.2, R425.1; also elsewhere on the board
/Amplifier/OUT_L-: R403.2, R405.1; also elsewhere on the board
/Amplifier/OUT_R+: R424.2, R426.1; also elsewhere on the board
/Amplifier/OUT_R-: R404.2, R406.1; also elsewhere on the board
AGND: C401.2, C402.2, Q401.4, Q402.4, Q405.1 (E), Q406.1 (E), Q409.4, Q410.4, Q413.1 (E), Q414.1 (E), R409.2, R410.2, R427.2, R428.2, U401.11 (V-), U402.11 (V-); also elsewhere on the board
GNDREF: R411.2, R412.2, R421.2, R422.2, RV401.3, RV401.6, U401.5 (+), U401.12 (+), U402.5 (+), U402.12 (+); also elsewhere on the board
unnamed: Q401.1, Q401.2, R401.2
unnamed: Q401.3, Q407.1, R407.2, U401.1
unnamed: Q402.1, Q402.2, R402.2
unnamed: Q402.3, Q408.1, R408.2, U402.1
unnamed: Q401.6, Q403.3 (B)
unnamed: Q401.5, Q403.2 (C), R403.1
unnamed: Q402.6, Q404.3 (B)
unnamed: Q402.5, Q404.2 (C), R404.1
unnamed: Q405.3 (B), Q407.4
unnamed: Q405.2 (C), Q407.2, R405.2
unnamed: Q406.3 (B), Q408.4
unnamed: Q406.2 (C), Q408.2, R406.2
unnamed: Q407.3, Q407.5, R409.1
unnamed: Q408.3, Q408.5, R410.1
unnamed: Q409.1, Q409.2, R419.2
unnamed: Q409.3, Q415.1, R415.2, U401.8
unnamed: Q410.1, Q410.2, R420.2
unnamed: Q410.3, Q416.1, R416.2, U402.8
unnamed: Q409.6, Q411.3 (B)
unnamed: Q409.5, Q411.2 (C), R423.1
unnamed: Q410.6, Q412.3 (B)
unnamed: Q410.5, Q412.2 (C), R424.1
unnamed: Q413.3 (B), Q415.4
unnamed: Q413.2 (C), Q415.2, R425.2
unnamed: Q414.3 (B), Q416.4
unnamed: Q414.2 (C), Q416.2, R426.2
unnamed: Q415.3, Q415.5, R427.1
unnamed: Q416.3, Q416.5, R428.1
unnamed: R413.1, RV401.5, U401.3 (+)
unnamed: R407.1, R411.1, U401.2 (-)
unnamed: R413.2, R417.1, U401.6 (-)
unnamed: R417.2, U401.7, U401.10 (+)
unnamed: R415.1, R421.1, U401.9 (-)
unnamed: U401.13 (-), U401.14
unnamed: R414.1, RV401.2, U402.3 (+)
unnamed: R408.1, R412.1, U402.2 (-)
unnamed: R414.2, R418.1, U402.6 (-)
unnamed: R418.2, U402.7, U402.10 (+)
unnamed: R416.1, R422.1, U402.9 (-)
unnamed: U402.13 (-), U402.14
V+: C401.1, C402.1, Q403.1 (E), Q404.1 (E), Q407.6, Q408.6, Q411.1 (E), Q412.1 (E), Q415.6, Q416.6, R401.1, R402.1, R419.1, R420.1, U401.4 (V+), U402.4 (V+); also elsewhere on the board

Notes on the sheet:
ボリューム用つまみ
Ra=Rb, A=(Rc+Rd)/Rd
シングルエンド‐差動変換 増幅段
可変抵抗
出力段
やっぱヒートシンクこれで 長い一体のもの，8℃/W ダメだったら空冷で
100~200mAくらい
ヒートシンク
最大電圧，最大ボリュームでクリップしないように設定 ラインIN(MAX)：400mVp-p これに合わせてPCM5102A出力も分圧(約14:1) EQで最大+10dB -> 4Vp-p これを電圧増幅段で5倍して20Vp-p
LME49740NA

Board: 6 copper layers, 140.0 x 100.0 mm, 199 parts (12 on the bottom side), 142 nets.
